# Keil uVision project Lab9.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: code
  AfterMake: fromelf -bin code.axf -o code.bin
  AfterMake: fromelf -cvf code.axf --vhx --32x1 -o code.hex
  c flags: Optim=2 uC99=1 uGnu=1 v6LangP=5
  c include: .\Device;.\Application;.\core
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ./Application/: cm0dsasm.s core_cm0.h core_cmFunc.h core_cmInstr.h edk_api.c edk_api.h EDK_CM0.h edk_driver.c edk_driver.h main.c retarget.c
software components: CMSIS:CORE 5.6.0
